# Keil uVision project test1.uvproj, settings and files
target LED_KEY (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: main.c
